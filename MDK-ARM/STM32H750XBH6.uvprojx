# Keil uVision project STM32H750XBH6.uvprojx, settings and files
target STM32H750XBH6 (6240000::V6.24::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750XBH6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/User/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../demos;../demos/benchmark;../demos/keypad_encoder;../demos/music;../demos/music/assets;../demos/stress;../demos/widgets;../examples;../examples/anim;../examples/event;../examples/get_started;../examples/layouts;../examples/layouts/flex;../examples/layouts/grid;../examples/libs;../examples/libs/bmp;../examples/libs/ffmpeg;../examples/libs/freetype;../examples/libs/gif;../examples/libs/png;../examples/libs/qrcode;../examples/libs/rlottie;../examples/libs/sjpg;../examples/others;../examples/others/fragment;../examples/others/gridnav;../examples/others/ime;../examples/others/imgfont;../examples/others/monkey;../examples/others/msg;../examples/others/snapshot;../examples/porting;../examples/scroll;../examples/styles;../examples/widgets;../src;../src/core;../src/draw;../src/draw/arm2d;../src/draw/nxp/pxp;../src/draw/nxp/vglite;../src/draw/renesas;../src/draw/sdl;../src/draw/stm32_dma2d;../src/draw/sw;../src/draw/swm341_dma2d;../src/extra;../src/extra/layouts;../src/extra/layouts/flex;../src/extra/layouts/grid;../src/extra/libs;../src/extra/libs/bmp;../src/extra/libs/ffmpeg;../src/extra/libs/freetype;../src/extra/libs/fsdrv;../src/extra/libs/gif;../src/extra/libs/png;../src/extra/libs/qrcode;../src/extra/libs/rlottie;../src/extra/libs/sjpg;../src/extra/libs/tiny_ttf;../src/extra/others;../src/extra/others/fragment;../src/extra/others/gridnav;../src/extra/others/ime;../src/extra/others/imgfont;../src/extra/others/monkey;../src/extra/others/msg;../src/extra/others/snapshot;../src/extra/themes;../src/extra/themes/basic;../src/extra/themes/default;../src/extra/themes/mono;../src/extra/widgets;../src/extra/widgets/animimg;../src/extra/widgets/calendar;../src/extra/widgets/chart;../src/extra/widgets/colorwheel;../src/extra/widgets/imgbtn;../src/extra/widgets/keyboard;../src/extra/widgets/led;../src/extra/widgets/list;../src/extra/widgets/menu;../src/extra/widgets/meter;../src/extra/widgets/msgbox;../src/extra/widgets/span;../src/extra/widgets/spinbox;../src/extra/widgets/spinner;../src/extra/widgets/tabview;../src/extra/widgets/tileview;../src/extra/widgets/win;../src/font;../src/hal;../src/misc;../src/widgets;../lvgl-8.4.0;../lvgl-8.4.0/examples/porting;../lvgl-8.4.0/demos/widgets;../lvgl-8.4.0/demos/widgets/assets;../My_LVGL;../APP
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x2000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H750XBH6\STM32H750XBH6.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/User
    ../Drivers/User/Src/: led.c usart.c sdram.c lcd_fonts.c lcd_image.c lcd_rgb.c touch_iic.c touch_800x480.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group LVGL
    ../lvgl-8.4.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl-8.4.0/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl-8.4.0/src/draw/arm2d/: lv_gpu_arm2d.c
    ../lvgl-8.4.0/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../lvgl-8.4.0/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../lvgl-8.4.0/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../lvgl-8.4.0/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../lvgl-8.4.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../lvgl-8.4.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl-8.4.0/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../lvgl-8.4.0/src/extra/layouts/flex/: lv_flex.c
    ../lvgl-8.4.0/src/extra/layouts/grid/: lv_grid.c
    ../lvgl-8.4.0/src/extra/libs/bmp/: lv_bmp.c
    ../lvgl-8.4.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl-8.4.0/src/extra/libs/freetype/: lv_freetype.c
    ../lvgl-8.4.0/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl-8.4.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../lvgl-8.4.0/src/extra/libs/png/: lodepng.c lv_png.c
    ../lvgl-8.4.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl-8.4.0/src/extra/libs/rlottie/: lv_rlottie.c
    ../lvgl-8.4.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lvgl-8.4.0/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../lvgl-8.4.0/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl-8.4.0/src/extra/others/gridnav/: lv_gridnav.c
    ../lvgl-8.4.0/src/extra/others/ime/: lv_ime_pinyin.c
    ../lvgl-8.4.0/src/extra/others/imgfont/: lv_imgfont.c
    ../lvgl-8.4.0/src/extra/others/monkey/: lv_monkey.c
    ../lvgl-8.4.0/src/extra/others/msg/: lv_msg.c
    ../lvgl-8.4.0/src/extra/others/snapshot/: lv_snapshot.c
    ../lvgl-8.4.0/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl-8.4.0/src/extra/themes/default/: lv_theme_default.c
    ../lvgl-8.4.0/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl-8.4.0/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl-8.4.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl-8.4.0/src/extra/widgets/chart/: lv_chart.c
    ../lvgl-8.4.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl-8.4.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl-8.4.0/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl-8.4.0/src/extra/widgets/led/: lv_led.c
    ../lvgl-8.4.0/src/extra/widgets/list/: lv_list.c
    ../lvgl-8.4.0/src/extra/widgets/menu/: lv_menu.c
    ../lvgl-8.4.0/src/extra/widgets/meter/: lv_meter.c
    ../lvgl-8.4.0/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl-8.4.0/src/extra/widgets/span/: lv_span.c
    ../lvgl-8.4.0/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl-8.4.0/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl-8.4.0/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl-8.4.0/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl-8.4.0/src/extra/widgets/win/: lv_win.c
    ../lvgl-8.4.0/src/extra/: lv_extra.c
    ../lvgl-8.4.0/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl-8.4.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl-8.4.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl-8.4.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Porting
    ../lvgl-8.4.0/examples/porting/: lv_port_disp.c lv_port_indev.c
    ../lvgl-8.4.0/: lv_conf.h
  group LVGL_DEMO
    ../lvgl-8.4.0/demos/widgets/: lv_demo_widgets.c
    ../lvgl-8.4.0/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group My_LVGL
    ../My_LVGL/: ui.c ui.h ui_helpers.c ui_helpers.h
    ../My_LVGL/screens/: ui_Screen1.c ui_Screen1.h
    ../My_LVGL/images/: ui_img_tsuki_ni_yorisou_otome_no_sahou_png.c ui_img_1033704984.c ui_img_gemini_generated_image_flbzrbflbzrbflbz_png.c ui_img_gemini_generated_image_jb1wkajb1wkajb1w_png.c ui_img_mini1_png.c
  group APP
    ../APP/: wifi.c wifi.h postoffice.c postoffice.h panelchange.c panelchange.h Wave.c Wave.h
software components: CMSIS:CORE 5.5.0
